Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-10-24T16:08:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 24 16:08:21 2022 * Host: DSBIRNE-RO-LE * Database: C:\Users\DSbirne\AppData\Local\Temp\4a2a7b7e-aaa6-4ace-aaff-4e93a8de6c4c\4c3d6e74-1d34-400c-8fb4-2edaced1d0c7\ifc * Database version: 5507 * Database creation date: Mon Oct 24 16:08:20 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Oct 24 16:08:20 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 24 16:08:21 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcDistributionPort, Port_4202670
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcOutlet: 2CKA001012A1598, E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001012A1598_NL-EN:2CKA001012A1598:4202675
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RGB 150-150-150
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 10 mm; Height: 71 mm; Rounding Radius: 4 mm; Width: 71 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM
Type - Identity Data - Article Code: Default; Article Description: Rocker Switch Mechanism, Inserts for flush-mounted switch ranges; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: yes; Description: Rocker Switch Mechanism, Inserts for flush-mounted switch ranges; EMCS Version: 4.0; ETIM Article Class: EC001590; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395541005; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001012A1598; Manufacturer Type: 2000/6 USR-503; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395541005&LanguageCode=NL&Country=NL; MEPcontent Class: ELECTRICAL_FIXTURES; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Revit Version: 2020; Type Name: 2CKA001012A1598; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001012A1598_NL-EN
Type - Pset_EnvironmentalImpactIndicators - Reference: 2CKA001012A1598
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: 2CKA001012A1598
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00701291 m2; Volume: 0.0000522726 m3
Identity Data - Copyright: © Trimble Europe BV; Mark: 3; VERSION: 220800
Other - Family: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001012A1598_NL-EN: 2CKA001012A1598; Family and Type: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001012A1598_NL-EN: 2CKA001012A1598; Type: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001012A1598_NL-EN: 2CKA001012A1598; Type Id: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001012A1598_NL-EN: 2CKA001012A1598
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: Busch-balance SI_2CKA001725A1555_hor_1, E_Frame_Switch Two-way_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_NL-EN:Busch-balance SI_2CKA001725A1555_hor_1:4202670
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9010
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 11 mm; Frame Thickness: 15 mm; Gang Height: 56 mm; Gang Width: 56 mm; Height: 81 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Rounding Gang: 1 mm; Rounding Radius: 2 mm; Width: 81 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM; Frame Type: Alpine white; Material: Color RAL 9010; Number of Gangs: 1
Type - Identity Data - Article Code: Default; Article Description: Cover frame, alpine white, Cover frame Busch-Balance SI; Article Type: 1-gang frame; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: no; Description: Cover frame, alpine white, Cover frame Busch-Balance SI; EMCS Version: 4.0; ETIM Article Class: EC000007; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395191460; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001725A1555; Manufacturer Type: 1721-914; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395191460&LanguageCode=NL&Country=NL; MEPcontent Class: ELECTRICAL_FIXTURES; Model: 1-gang frame; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Product Line: Busch-balance SI; Revit Version: 2020; Type Name: Busch-balance SI_2CKA001725A1555_hor_1; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Frame_Switch Two-way_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_NL-EN
Type - Pset_EnvironmentalImpactIndicators - Reference: Busch-balance SI_2CKA001725A1555_hor_1
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: Busch-balance SI_2CKA001725A1555_hor_1
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm
Dimensions - Area: 0.0131519 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.0000323103 m3
Electrical - Loads - Power: 0 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 2; VERSION: 220800
Other - Family: E_Frame_Switch Two-way_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_NL-EN: Busch-balance SI_2CKA001725A1555_hor_1; Family and Type: E_Frame_Switch Two-way_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_NL-EN: Busch-balance SI_2CKA001725A1555_hor_1; Gang 3: 0 mm; Gang Reference Line: 56 mm; Interior Width: 28 mm; Number of Representation Line: 2; Type: E_Frame_Switch Two-way_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_NL-EN: Busch-balance SI_2CKA001725A1555_hor_1; Type Id: E_Frame_Switch Two-way_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_NL-EN: Busch-balance SI_2CKA001725A1555_hor_1
Phasing - Phase Created: 4. Plan over 10 years

# IfcSwitchingDevice: Busch-balance SI_2-Way_2CKA001731A2002, E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001731A2002_NL-EN:Busch-balance SI_2-Way_2CKA001731A2002:4202674
In: F00
Type - PredefinedType: CONTACTOR; Material: Color RAL 9010
Type - Constraints - Default Elevation: 1050 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 11 mm; Height: 55 mm; Rounding Radius: 1 mm; Width: 55 mm
Type - Electrical - Material: Color RAL 9010; App ID: EL_MODELPARTSYSTEM; Insert Type: Alpine white
Type - Identity Data - Custom: no; Article Code: Default; Article Description: Rocker, alpine white, Covers for switches/push-buttons; Base Family Version: 20221003; Category: EL_SINGLEPOLESWITCH; Content Supplier URL: www.MEPcontent.com; Description: Rocker, alpine white, Covers for switches/push-buttons; EMCS Version: 4.0; ETIM Article Class: EC000011; Family Version: 11.21; GLN: 8712507900012; GTIN: 4011395190210; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001731A2002; Manufacturer Type: 2506-914; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395190210&LanguageCode=NL&Country=NL; MEPcontent Class: LIGHTING_DEVICES; OmniClass Number: 23.80.00.00; OmniClass Title: Electric Power and Lighting; Product Line: Busch-balance SI; Revit Version: 2020; Type Name: Busch-balance SI_2-Way_2CKA001731A2002; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Lighting Devices; Family Name: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001731A2002_NL-EN
Type - Visibility - Number Of Representation: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: Busch-balance SI_2-Way_2CKA001731A2002
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_SwitchingDeviceTypeCommon - Reference: Busch-balance SI_2-Way_2CKA001731A2002
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00781076 m2; Volume: 0.000041523 m3
Identity Data - Annotation: 1; Copyright: © Trimble Europe BV; Mark: 1; VERSION: 220800
Other - Annotation SwitchTwoWay: yes; Family: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001731A2002_NL-EN: Busch-balance SI_2-Way_2CKA001731A2002; Family and Type: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001731A2002_NL-EN: Busch-balance SI_2-Way_2CKA001731A2002; Type: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001731A2002_NL-EN: Busch-balance SI_2-Way_2CKA001731A2002; Type Id: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001731A2002_NL-EN: Busch-balance SI_2-Way_2CKA001731A2002
Phasing - Phase Created: 4. Plan over 10 years
